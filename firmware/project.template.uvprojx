# Keil uVision project project.template.uvprojx, settings and files
target project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\bsp\ADC;..\bsp\BEEP;..\bsp\DHT11;..\bsp\EXTI;..\bsp\KEY;..\bsp\LCD;..\bsp\LED;..\bsp\SPI;..\bsp\TIMER;..\driver_core;..\freertos\include;..\lib\inc;..\system\delay;..\system\sys;..\system\usart;..\usr;..\freertos\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group bsp
    ../bsp/ADC/: adc.c
    ../bsp/BEEP/: beep.c
    ../bsp/DHT11/: dht11.c
    ../bsp/EXTI/: exti.c
    ../bsp/KEY/: key.c
    ../bsp/LCD/: GUI.c lcd.c
    ../bsp/LED/: led.c
    ../bsp/SPI/: SPI.c
    ../bsp/TIMER/: timer.c
  group driver_core
    ../driver_core/: core_cm3.c startup_stm32f10x_md.s
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group system
    ../system/delay/: delay.c
    ../system/sys/: sys.c
    ../system/usart/: usart.c
  group freertos
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/portable/RVDS/ARM_CM3/: port.c
    ../freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group usr
    ./: main.c stm32f10x_it.c system_stm32f10x.c
