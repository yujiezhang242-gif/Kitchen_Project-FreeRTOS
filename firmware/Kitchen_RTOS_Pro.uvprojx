# Keil uVision project Kitchen_RTOS_Pro.uvprojx, settings and files
target Kitchen_RTOS_Pro (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0xF800) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: kitchen_rtos +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: app;board;..\core;..\services;vendor;vendor\driver_core;vendor\lib\inc;vendor\freertos\include;vendor\freertos\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xF800
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\kitchen.sct
  group App
    app/: main.c faults.c retarget.c
  group Core
    ../core/: kitchen.c
  group Services
    ../services/: wire.c config_store.c runtime.c health.c dht_decoder.c timing.c text.c crash.c
  group Board
    board/: board.c oled.c
  group CMSIS
    vendor/: system_stm32f10x.c
    vendor/driver_core/: core_cm3.c startup_stm32f10x_md.s
  group STM32 SPL
    vendor/lib/src/: misc.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_iwdg.c
  group FreeRTOS
    vendor/freertos/: tasks.c queue.c list.c
    vendor/freertos/portable/RVDS/ARM_CM3/: port.c
